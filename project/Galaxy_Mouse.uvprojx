# Keil uVision project Galaxy_Mouse.uvprojx, settings and files
target Galaxy_Mouse (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: SN32F247BF SONiX
  pack: SONiX.SN32F2_DFP.1.2.8
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0xFFFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Galaxy_Mouse +hex
  AfterMake: C:\Slash\work\git_source\XANOVA_M380_Mouse\project\Bin\MergeHex.bat
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\source\inc;..\avago3389\inc
  memory RVCT4: ROM 0x0 size 0xb000
  memory RVCT5: ROM 0xfc00 size 0x3fc
  memory RVCT9: RAM 0x20000000 size 0x2000
  group source
    ../source/: button.c CT16B0.c CT16B1.c FlashPrg.c gpio.c hidram.c hiduser.c keyboard.c macro.c main.c mouse.c PowerManagement.c profile.c protocol.c SPI0.c storage.c timer.c usbdesc.c usbepfunc.c usbhw.c usbram.c usbuser.c Utility.c variables.c wdt.c LED.c LED_Table.c LED_Function.c LED_RamSetting.c led_driver.c
  group Avago
    ../avago3389/: avago_api.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.1.0
